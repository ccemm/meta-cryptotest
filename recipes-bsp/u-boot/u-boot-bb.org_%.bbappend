FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://ab-boot.cfg"
